# Keil uVision project hello_driver.uvprojx, settings and files
target hello (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.4
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_driver +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: ..\..\..\libraries\drivers\inc;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\at32f435_437_board;..\inc;..\..\dm9051_lw;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\at32f435_437_board
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
    ../../dm9051_lw/: dm9051_lw_conf.c dm9051_lw.c dm9051opts.c
  group bsp
    ../../../at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f435_437_gpio.c at32f435_437_crm.c at32f435_437_usart.c at32f435_437_misc.c at32f435_437_spi.c at32f435_437_exint.c at32f435_437_scfg.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group readme
    ../: readme.txt
    ../../dm9051_lw/: info.txt
