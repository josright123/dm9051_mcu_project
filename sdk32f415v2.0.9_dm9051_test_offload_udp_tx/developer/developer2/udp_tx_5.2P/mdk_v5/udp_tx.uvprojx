# Keil uVision project udp_tx.uvprojx, settings and files
target udp_tx_9051 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F415RCT7-7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.9
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: udp_tx_9051 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\inc;..\..\..\..\at32f415_board;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\src;..\..\..\dm9051_lw2312v1_5.2P;..\..\lwip_src\include;..\..\lwip_src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_clock.c at32f415_int.c tmr_init.c
    ../../../dm9051_lw2312v1_5.2P/: dm9051_lw.c dm9051_lw_conf.c dm9051_lw_log.c
  group bsp
    ../../../../at32f415_board/: at32f415_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f415_crm.c at32f415_usart.c at32f415_gpio.c at32f415_misc.c at32f415_spi.c at32f415_tmr.c at32f415_exint.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
  group readme
    ../: readme.txt
  group usr_1
    ../src/testproc/: testproc_main.c testproc_lw.c timeo.c timeo_not.c netifo.c
    ../: dhcp.c inet_chksum.c def.c
