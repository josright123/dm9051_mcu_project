# Keil uVision project hello_link.uvprojx, settings and files
target hello_link_9051 (ARM-ADS)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.6
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hellol_ink_9051 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVCT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\inc;..\..\..\..\at32f403a_407_board;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\src;..\..\..\dm9051_lw2312v1_5.2P
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c at32f403a_407_clock.c at32f403a_407_int.c tmr_init.c
    ../../../dm9051_lw2312v1_5.2P/: dm9051_lw.c dm9051_lw_conf.c dm9051opts.c
    ../src/usart3proc/: usart3proc_fun.c
    ../src/dm9051a/: dm9051a_eep.c
  group bsp
    ../../../../at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_usart.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_exint.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group readme
    ../: readme.txt
  group usr_1
    ../src/testproc/: testproc_main.c
